# CATIA V5 part "Part10.CATPart"
Saved by CATIA V5R20 SP7, build 01-25-2012
Part number: bâti
Stored file links:
  U:\IAO\thinkmotion catia2\Part10.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)