# CATIA V5 part "Part11.CATPart"
Saved by CATIA V5R20 SP5, build 01-14-2011
Part number: secteur_denté
Stored file links:
  F:\Catia_finish\Part11.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)