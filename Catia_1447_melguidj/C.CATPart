# CATIA V5 part "C.CATPart"
Saved by CATIA V5R20 SP5, build 01-14-2011
Part number: C
Stored file links:
  E:\IAO_2010\iao\IAO_MMS_Groupe2\IAO_MMS_Groupe2\melguidj\Catia\C.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)