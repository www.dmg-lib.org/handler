# CATIA V5 part "B.CATPart"
Saved by CATIA V5R20 SP5, build 01-14-2011
Part number: B
Stored file links:
  E:\IAO_2010\iao\IAO_MMS_Groupe2\IAO_MMS_Groupe2\melguidj\Catia\B.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)