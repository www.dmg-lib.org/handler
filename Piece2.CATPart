# CATIA V5 part "Piece2.CATPart"
Saved by CATIA V5R20 SP1, build 01-28-2010
Part number: Piece2
Stored file links:
  F:\TRAV\IAO\Exercice IAO\Catia\Piece2.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)