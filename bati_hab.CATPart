# CATIA V5 part "bati_hab.CATPart"
Saved by CATIA V5R20 SP0, build 10-29-2009
Part number: bati_hab
Stored file links:
  C:\Users\Cédric\Documents\IFMA-2A\IAO\Projet IAO\ccascaro\bati_hab.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Body1 (main body)